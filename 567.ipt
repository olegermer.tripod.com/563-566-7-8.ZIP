# Autodesk Inventor part: 567
## iProperties
Author: Administrator
Shininess: 64.0
Angle Display Precision: 2
Document Length Units: 11272
Document Angle Units: 11286
Document Time Units: 11279
Document Mass Units: 11290
Document Length Units Precision: 3
Document Angle Units Precision: 2
Compacted: True
PropertySet Name: _Private Model Information
Created: 2002-03
Part Number: 567
Material: Stainless Steel, 440C
Document SubType Name: Modeling
Designer: Administrator
Control State: 0
Master: False
Checked Out: False
PropertySet Name: Design Tracking Control
Density: 0.0
Volumn: 0.0
Area: 0.0
PropertySet Name: Model Information
## Feature names
1. Revolution1
